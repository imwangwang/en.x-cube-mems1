# IAR project Project.ewp, settings and files
configuration STM32L1xx-Nucleo-IKS01A3 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152RE ST STM32L152RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L152xE; USE_HAL_DRIVER; USE_STM32L1XX_NUCLEO; USE_IKS01A3
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L1xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\..\Drivers\BSP\Components\lis2dw12; ..\..\..\..\..\..\Drivers\BSP\Components\lps22hh; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dso; ..\..\..\..\..\..\Drivers\BSP\Components\lis2mdl; ..\..\..\..\..\..\Drivers\BSP\Components\stts751; ..\..\..\..\..\..\Drivers\BSP\IKS01A3; ..\..\..\..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l152xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12.c lis2dw12_reg.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../../../../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Drivers/BSP/IKS01A3
    ../../../../../../Drivers/BSP/IKS01A3/: iks01a3_env_sensors.c iks01a3_env_sensors_ex.c iks01a3_motion_sensors.c iks01a3_motion_sensors_ex.c
  group Drivers/BSP/STM32L1xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group Example/EWARM
    ./: startup_stm32l152xe.s
  group Example/User
    ../Src/: com.c cube_hal_l1.c DemoDatalog.c DemoSerial.c main.c MotionAW_Manager.c MotionPW_Manager.c nucleo_l152re_bus.c serial_protocol.c stm32l1xx_hal_msp.c stm32l1xx_it.c
  group Middlewares/STM32_MotionAW_Library
    ../../../../../../Middlewares/ST/STM32_MotionAW_Library/Lib/: MotionAW_CM3_wc32_ot.a
  group Middlewares/STM32_MotionPW_Library
    ../../../../../../Middlewares/ST/STM32_MotionPW_Library/Lib/: MotionPW_CM3_wc32_ot.a

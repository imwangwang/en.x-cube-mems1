# Keil uVision project Project.uvprojx, settings and files
target STM32L1xx-Nucleo-IKS01A3 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x14000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L1xx-Nucleo-IKS01A3 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\STM32L1xx-Nucleo-IKS01A3\Objects\@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L152xE,USE_HAL_DRIVER,USE_STM32L1XX_NUCLEO,USE_IKS01A3
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32L1xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lps22hh;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dso;..\..\..\..\..\..\Drivers\BSP\Components\lis2dw12;..\..\..\..\..\..\Drivers\BSP\Components\lis2mdl;..\..\..\..\..\..\Drivers\BSP\Components\stts751;..\..\..\..\..\..\Drivers\BSP\IKS01A3;..\..\..\..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12.c lis2dw12_reg.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Drivers/BSP/STM32L1xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Drivers/BSP/IKS01A3
    ../../../../../../Drivers/BSP/IKS01A3/: iks01a3_env_sensors.c iks01a3_env_sensors_ex.c iks01a3_motion_sensors.c iks01a3_motion_sensors_ex.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_gpio.c stm32l1xx_hal.c stm32l1xx_hal_dma.c stm32l1xx_hal_cortex.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_uart.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_i2c.c stm32l1xx_hal_spi.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_crc.c
  group Example/MDK-ARM
    ./: startup_stm32l152xe.s
  group Example/User
    ../Src/: DemoSerial.c MotionAW_Manager.c com.c main.c stm32l1xx_hal_msp.c cube_hal_l1.c stm32l1xx_it.c serial_protocol.c DemoDatalog.c MotionPW_Manager.c nucleo_l152re_bus.c
  group Middlewares/STM32_MotionAW_Library
    ../../../../../../Middlewares/ST/STM32_MotionAW_Library/Lib/: MotionAW_CM3_wc16_ot.a
  group Middlewares/STM32_MotionPW_Library
    ../../../../../../Middlewares/ST/STM32_MotionPW_Library/Lib/: MotionPW_CM3_wc16_ot.a

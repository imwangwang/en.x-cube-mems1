# IAR project Project.ewp, settings and files
configuration STM32L1xx-Nucleo-IKS02A1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152RE ST STM32L152RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L152xE; USE_HAL_DRIVER; USE_STM32L1XX_NUCLEO; USE_IKS02A1
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L1xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\iis2dlpc; ..\..\..\..\..\..\Drivers\BSP\Components\iis2mdc; ..\..\..\..\..\..\Drivers\BSP\Components\ism330dhcx; ..\..\..\..\..\..\Drivers\BSP\IKS02A1; ..\..\..\..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l152xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/iis2dlpc/: iis2dlpc.c iis2dlpc_reg.c
    ../../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
    ../../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
  group Drivers/BSP/IKS02A1
    ../../../../../../Drivers/BSP/IKS02A1/: iks02a1_motion_sensors.c iks02a1_motion_sensors_ex.c
  group Drivers/BSP/STM32L1xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group Example/EWARM
    ./: startup_stm32l152xe.s
  group Example/User
    ../Src/: com.c cube_hal_l1.c DemoSerial.c main.c MotionEC_Manager.c MotionMC_Manager.c nucleo_l152re_bus.c serial_protocol.c stm32l1xx_hal_msp.c stm32l1xx_it.c
  group Middlewares/STM32_MotionEC_Library
    ../../../../../../Middlewares/ST/STM32_MotionEC_Library/Lib/: MotionEC_CM3_wc32_ot.a
  group Middlewares/STM32_MotionMC_Library
    ../../../../../../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM3_wc32_ot.a

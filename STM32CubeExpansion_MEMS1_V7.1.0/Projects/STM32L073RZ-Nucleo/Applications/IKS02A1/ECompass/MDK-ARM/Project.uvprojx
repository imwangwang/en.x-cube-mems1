# Keil uVision project Project.uvprojx, settings and files
target STM32L0xx-Nucleo-IKS02A1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: STM32L0xx-Nucleo-IKS02A1 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\STM32L0xx-Nucleo-IKS02A1\Objects\@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L073xx,USE_HAL_DRIVER,USE_STM32L0XX_NUCLEO, USE_IKS02A1
  c include: ..\Inc;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\ism330dhcx;..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\IKS02A1;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\Components\iis2dlpc;..\..\..\..\..\..\Drivers\BSP\Components\iis2mdc;..\..\..\..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../../../../Drivers/BSP/Components/iis2dlpc/: iis2dlpc.c iis2dlpc_reg.c
    ../../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
  group Drivers/BSP/STM32L0xx-Nucleo
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/BSP/IKS02A1
    ../../../../../../Drivers/BSP/IKS02A1/: iks02a1_motion_sensors.c iks02a1_motion_sensors_ex.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_gpio.c stm32l0xx_hal_uart.c stm32l0xx_hal_dma.c stm32l0xx_hal_cortex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_spi.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_crc.c
  group Example/MDK-ARM
    ./: startup_stm32l073xx.s
  group Example/User
    ../Src/: DemoSerial.c MotionEC_Manager.c MotionMC_Manager.c com.c main.c stm32l0xx_hal_msp.c cube_hal_l0.c stm32l0xx_it.c serial_protocol.c nucleo_l073rz_bus.c
  group Middlewares/STM32_MotionEC_Library
    ../../../../../../Middlewares/ST/STM32_MotionEC_Library/Lib/: MotionEC_CM0P_wc16_ot.a
  group Middlewares/STM32_MotionMC_Library
    ../../../../../../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM0P_wc16_ot.a

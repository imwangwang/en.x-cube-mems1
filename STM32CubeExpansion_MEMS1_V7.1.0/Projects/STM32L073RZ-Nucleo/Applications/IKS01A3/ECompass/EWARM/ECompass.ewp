# IAR project ECompass.ewp, settings and files
configuration ECompass (ARM, debug)
  General.OGChipSelectEditMenu: STM32L073RZ ST STM32L073RZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L073xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/ST/STM32_MotionEC_Library/Inc; ../../../../../../Drivers/BSP/Components/lsm6dso; ../../../../../../Drivers/BSP/Components/lis2dw12; ../../../../../../Drivers/BSP/Components/lis2mdl; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps22hh; ../../../../../../Drivers/BSP/Components/stts751; ../../../../../../Drivers/BSP/IKS01A3; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Middlewares/ST/STM32_MotionMC_Library/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ECompass.hex
  ILINK.IlinkOutputFile: ECompass.out
  ILINK.IlinkIcfFile: stm32l073xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l073xx.s
  group Application/User
    ../Src/: main.c com.c demo_serial.c serial_protocol.c iks01a3_mems_control.c iks01a3_mems_control_ex.c motion_mc_manager.c motion_ec_manager.c app_x-cube-mems1.c stm32l0xx_nucleo_bus.c stm32l0xx_nucleo.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso_reg.h lsm6dso.h lsm6dso_reg.c lsm6dso.c
    ../../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12_reg.h lis2dw12.h lis2dw12_reg.c lis2dw12.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl_reg.h lis2mdl.h lis2mdl_reg.c lis2mdl.c
    ../../../../../../Drivers/BSP/Components/hts221/: hts221_reg.h hts221.h hts221_reg.c hts221.c
    ../../../../../../Drivers/BSP/Components/lps22hh/: lps22hh_reg.h lps22hh.h lps22hh_reg.c lps22hh.c
    ../../../../../../Drivers/BSP/Components/stts751/: stts751_reg.h stts751.h stts751_reg.c stts751.c
    ../../../../../../Drivers/BSP/Components/Common/: motion_sensor.h env_sensor.h
  group Drivers/BSP/IKS01A3
    ../../../../../../Drivers/BSP/IKS01A3/: iks01a3_motion_sensors.h iks01a3_motion_sensors_ex.h iks01a3_env_sensors.h iks01a3_env_sensors_ex.h iks01a3_motion_sensors.c iks01a3_motion_sensors_ex.c iks01a3_env_sensors.c iks01a3_env_sensors_ex.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Middlewares/MEMS/Motion Library/MotionEC
    ../../../../../../Middlewares/ST/STM32_MotionEC_Library/Lib/: MotionEC_CM0P_wc32_ot.a
    ../../../../../../Middlewares/ST/STM32_MotionEC_Library/Inc/: motion_ec.h
  group Middlewares/MEMS/Motion Library/MotionMC
    ../../../../../../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM0P_wc32_ot.a
    ../../../../../../Middlewares/ST/STM32_MotionMC_Library/Inc/: motion_mc.h motion_mc_cm0p.h

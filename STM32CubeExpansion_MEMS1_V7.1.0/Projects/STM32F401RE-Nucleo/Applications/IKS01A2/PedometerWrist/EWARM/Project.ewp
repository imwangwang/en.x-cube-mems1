# IAR project Project.ewp, settings and files
configuration STM32F4xx-Nucleo-IKS01A2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F401xE; USE_HAL_DRIVER; USE_STM32F4XX_NUCLEO; USE_IKS01A2
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr; ..\..\..\..\..\..\Drivers\BSP\Components\lps22hb; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsl; ..\..\..\..\..\..\Drivers\BSP\IKS01A2; ..\..\..\..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc; ..\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c lps22hb_reg.c
    ../../../../../../Drivers/BSP/Components/lsm303agr/: lsm303agr.c lsm303agr_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c lsm6dsl_reg.c
  group Drivers/BSP/IKS01A2
    ../../../../../../Drivers/BSP/IKS01A2/: iks01a2_env_sensors.c iks01a2_env_sensors_ex.c iks01a2_motion_sensors.c iks01a2_motion_sensors_ex.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Example/EWARM
    ./: startup_stm32f401xe.s
  group Example/User
    ../Src/: com.c cube_hal_f4.c DemoDatalog.c DemoSerial.c main.c MotionAW_Manager.c MotionPW_Manager.c nucleo_f401re_bus.c serial_protocol.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Middlewares/STM32_MotionAW_Library
    ../../../../../../Middlewares/ST/STM32_MotionAW_Library/Lib/: MotionAW_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionPW_Library
    ../../../../../../Middlewares/ST/STM32_MotionPW_Library/Lib/: MotionPW_CM4F_wc32_ot.a

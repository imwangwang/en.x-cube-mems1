# Keil uVision project DataLogTerminal.uvprojx, settings and files
target DataLogTerminal (ARM-ADS)
  device: STM32F401RETx STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: DataLogTerminal +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE
  c include: ../Inc;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/Components/iis2dlpc;../../../../../../Drivers/BSP/Components/iis2mdc;../../../../../../Drivers/BSP/Components/ism330dhcx;../../../../../../Drivers/BSP/IKS02A1;../../../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../Src/: main.c app_x-cube-mems1.c stm32f4xx_nucleo_bus.c stm32f4xx_nucleo.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/iis2dlpc/: iis2dlpc_reg.c iis2dlpc.c
    ../../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc_reg.c iis2mdc.c
    ../../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx_reg.c ism330dhcx.c
  group Drivers/BSP/IKS02A1
    ../../../../../../Drivers/BSP/IKS02A1/: iks02a1_motion_sensors.c iks02a1_motion_sensors_ex.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0

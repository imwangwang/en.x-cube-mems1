# Keil uVision project Project.uvprojx, settings and files
target STM32F401RE_NUCLEO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F401RE_NUCLEO +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\STM32F401RE_NUCLEO\Objects\@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F401xE,USE_HAL_DRIVER,USE_STM32F4XX_NUCLEO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\ism330dhcx;..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\..\..\..\..\Drivers\BSP\IKS02A1;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\Components\iis2dlpc;..\..\..\..\..\..\Drivers\BSP\Components\iis2mdc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../../../../Drivers/BSP/Components/iis2dlpc/: iis2dlpc.c iis2dlpc_reg.c
    ../../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/IKS02A1
    ../../../../../../Drivers/BSP/IKS02A1/: iks02a1_motion_sensors.c iks02a1_motion_sensors_ex.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_i2c_ex.c
  group Example/MDK-ARM
    ./: startup_stm32f401xe.s
  group Example/User
    ../Src/: cube_hal_f4.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c com.c demo_serial.c sensor_commands.c serial_protocol.c nucleo_f401re_bus.c

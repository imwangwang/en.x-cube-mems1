# IAR project ECompass.ewp, settings and files
configuration ECompass (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/ST/STM32_MotionEC_Library/Inc; ../../../../../../Drivers/BSP/Components/lsm6dsl; ../../../../../../Drivers/BSP/Components/lsm303agr; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps22hb; ../../../../../../Drivers/BSP/IKS01A2; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Middlewares/ST/STM32_MotionMC_Library/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ECompass.hex
  ILINK.IlinkOutputFile: ECompass.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: main.c com.c demo_serial.c serial_protocol.c iks01a2_mems_control.c iks01a2_mems_control_ex.c motion_mc_manager.c motion_ec_manager.c app_x-cube-mems1.c stm32l4xx_nucleo_bus.c stm32l4xx_nucleo.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl_reg.h lsm6dsl.h lsm6dsl_reg.c lsm6dsl.c
    ../../../../../../Drivers/BSP/Components/lsm303agr/: lsm303agr_reg.h lsm303agr.h lsm303agr_reg.c lsm303agr.c
    ../../../../../../Drivers/BSP/Components/hts221/: hts221_reg.h hts221.h hts221_reg.c hts221.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: lps22hb_reg.h lps22hb.h lps22hb_reg.c lps22hb.c
    ../../../../../../Drivers/BSP/Components/Common/: motion_sensor.h env_sensor.h
  group Drivers/BSP/IKS01A2
    ../../../../../../Drivers/BSP/IKS01A2/: iks01a2_motion_sensors.h iks01a2_motion_sensors_ex.h iks01a2_env_sensors.h iks01a2_env_sensors_ex.h iks01a2_motion_sensors.c iks01a2_motion_sensors_ex.c iks01a2_env_sensors.c iks01a2_env_sensors_ex.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/MEMS/Motion Library/MotionEC
    ../../../../../../Middlewares/ST/STM32_MotionEC_Library/Lib/: MotionEC_CM4F_wc32_ot.a
    ../../../../../../Middlewares/ST/STM32_MotionEC_Library/Inc/: motion_ec.h
  group Middlewares/MEMS/Motion Library/MotionMC
    ../../../../../../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM4F_wc32_ot.a
    ../../../../../../Middlewares/ST/STM32_MotionMC_Library/Inc/: motion_mc.h motion_mc_cm0p.h
